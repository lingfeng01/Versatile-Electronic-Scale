# Keil uVision project 多功能电子秤.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: 多功能电子秤 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App;.\divers;.\main
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
  group main
    ./main/: main.c
  group app
    ./App/: app_main.c
  group dives
    ./divers/: 1602LCD.c HX711.c systick.c stc_usb_cdc_8h_xdata_interrupt.LIB
